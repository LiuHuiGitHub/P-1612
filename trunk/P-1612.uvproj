# Keil uVision project P-1612.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: P-1612 +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: FM1702SL.c LED.c mifare.c normal.c 说明.txt
